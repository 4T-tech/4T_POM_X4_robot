# Keil uVision project rp2040_example.uvprojx, settings and files
target Pico (6240000::V6.24::ARMCLANG)
  device: RP2040:Core0 RPi
  pack: RaspberryPi.RP2xxx_DFP.0.9.5
  cpu: IRAM(0x20000000,0x00042000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rp2040_example
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\BSP;..\..\BSP\Inc;..\pico;..\..\Drivers\BSP\Components\lsm6dso;.\Core\Inc;..\..\Middlewares\ST\STM32_MotionFX_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x42000
  scatter file: .\RTE\Device\RP2040_Core0\rp2040.sct
  group APP
    ./: main.c gpio.c usart.c timers.c MadgwickAHRS.c
  group BSP
    ../../BSP/Src/: reg_protocol.c leg_ik.c Dog_Sport.c POM_lsm6dso.c esp32_control.c
  group Drivers/BSP
    ../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
  group Core/Src
    ./Core/Src/: rp2040_bus.c
software components: CMSIS:CORE 6.1.1, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:Pico Board 1.5.1, Device:Pico SDK 1.5.1, Device:Startup 1.1.0
